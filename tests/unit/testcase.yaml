## tests/unit/testcase.yaml
```yaml
tests:
  app.led_ctrl.unit:
    platform_allow:
      - native_sim
    integration_platforms:
      - native_sim
    tags:
      - unit
```
